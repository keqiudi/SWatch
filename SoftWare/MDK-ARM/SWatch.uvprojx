# Keil uVision project SWatch.uvprojx, settings and files
target SWatch (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: SWatch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,LV_CONF_INCLUDE_SIMPLE
  c misc: --locale=english
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares;../Middlewares/lvgl;../Middlewares/lvgl/src;../Middlewares/lvgl/port;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/I2C;../BSP/AHT20;../BSP/MPU6050;../BSP/LCD;../BSP/CST816T;../BSP/SPL06;../APP/User/Tasks/Inc;../APP/User/System;../APP/User/UI/;../APP/User/UI/screens/Inc;../APP/User/Utils/Inc;../APP/User/HWInterface/Inc;../Debug/RTT
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group App/User/System
    ../APP/User/System/: delay.c delay.h sys.h
  group App/User/User_Utils
    ../APP/User/Utils/Src/: page_manager.c
    ../APP/User/Utils/Inc/: page_manager.h
  group App/User/User_Task
    ../APP/User/Tasks/Src/: user_task_init.c user_hw_init.c user_lvgl_handler.c user_sensor_task.c
    ../APP/User/Tasks/Inc/: user_task_init.h user_hw_init.h user_lvgl_handler.h user_sensor_task.h
  group App/User/UI
    ../APP/User/UI/: ui_events.h ui.c ui.h ui_helpers.c ui_helpers.h
    ../APP/User/UI/screens/Src/: ui_HomePage.c ui_MenuPage.c ui_EnvironmentPage.c ui_HeartRatePage.c ui_SpO2MeasurePage.c ui_CalendarPage.c ui_TimerPage.c ui_CompassPage.c ui_SettingMenuPage.c ui_LTSetPage.c ui_SOffTimeSetPage.c ui_DateTimeMenuPage.c ui_DateSetPage.c ui_TimeSetPage.c ui_AboutPage.c
  group App/User/UI_Font
    ../APP/User/UI/fonts/: ui_font_OpenSasnsItalic15.c ui_font_OpenSasnsItalic100.c ui_font_CuYuan20.c ui_font_CuYuan30.c ui_font_CuYuan40.c ui_font_CuYuan60.c ui_font_ALiDaKai20.c ui_font_HPiconfont25.c ui_font_MPiconfont25.c ui_font_MPiconfont30.c ui_font_EPiconfont30.c ui_font_HRPiconfont50.c ui_font_O2MPiconfont50.c ui_font_TMPiconfont30.c ui_font_CPiconfont28.c ui_font_LTSiconfont40.c ui_font_SPiconfont30.c
    ../APP/User/UI/images/: ui_img_compass_needle_png.c
  group App/User/HWInterface
    ../APP/User/HWInterface/Src/: hw_interface.c hw_aht20_interface.c hw_mpu6050_interface.c
    ../APP/User/HWInterface/Inc/: hw_interface.h hw_aht20_interface.h hw_mpu6050_interface.h device.h
  group Drivers/User/BSP_Drivers
    ../BSP/CST816T/: bsp_touch_cst816t.c bsp_touch_cst816t.h
    ../BSP/LCD/: bsp_lcd_st7789.c bsp_lcd_st7789.h bsp_lcd.c bsp_lcd.h
    ../BSP/I2C/: i2c_hal.c i2c_hal.h
    ../BSP/AHT20/: bsp_aht20.c bsp_aht20.h
    ../BSP/MPU6050/: bsp_mpu6050.c bsp_mpu6050.h
    ../BSP/SPL06/: bsp_spl06.c bsp_spl06.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/lvgl/conf
    ../Middlewares/lvgl/: lv_version.h lv_conf.h lvgl.h
  group Middlewares/lvgl/port
    ../Middlewares/lvgl/port/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group Middlewares/lvgl/src
    ../Middlewares/lvgl/src/: lv_init.c
  group Middlewares/lvgl/src/core
    ../Middlewares/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group Middlewares/lvgl/src/display
    ../Middlewares/lvgl/src/display/: lv_display.c
  group Middlewares/lvgl/src/draw
    ../Middlewares/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../Middlewares/lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../Middlewares/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_nema_gfx_path.c
    ../Middlewares/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../Middlewares/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Middlewares/lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
    ../Middlewares/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../Middlewares/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../Middlewares/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../Middlewares/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
  group Middlewares/lvgl/src/font
    ../Middlewares/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/lvgl/src/indev
    ../Middlewares/lvgl/port/: lv_port_indev.h
    ../Middlewares/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group Middlewares/lvgl/src/layouts
    ../Middlewares/lvgl/src/layouts/: lv_layout.c
    ../Middlewares/lvgl/src/layouts/grid/: lv_grid.c
    ../Middlewares/lvgl/src/layouts/flex/: lv_flex.c
  group Middlewares/lvgl/src/libs
    ../Middlewares/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../Middlewares/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/lvgl/src/libs/bmp/: lv_bmp.c
    ../Middlewares/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../Middlewares/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../Middlewares/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../Middlewares/lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../Middlewares/lvgl/src/libs/libpng/: lv_libpng.c
    ../Middlewares/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Middlewares/lvgl/src/libs/lz4/: lz4.c
    ../Middlewares/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/lvgl/src/libs/rle/: lv_rle.c
    ../Middlewares/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../Middlewares/lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../Middlewares/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group Middlewares/lvgl/src/misc
    ../Middlewares/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_assert.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
  group Middlewares/lvgl/src/osal
    ../Middlewares/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group Middlewares/lvgl/src/stdlib
    ../Middlewares/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group Middlewares/lvgl/src/themes
    ../Middlewares/lvgl/src/themes/: lv_theme.c
    ../Middlewares/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/lvgl/src/themes/default/: lv_theme_default.c
  group Middlewares/lvgl/src/tick
    ../Middlewares/lvgl/src/tick/: lv_tick.c
  group Middlewares/lvgl/src/widgets
    ../Middlewares/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/lvgl/src/widgets/button/: lv_button.c
    ../Middlewares/lvgl/src/widgets/image/: lv_image.c
    ../Middlewares/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../Middlewares/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../Middlewares/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/lvgl/src/widgets/chart/: lv_chart.c
    ../Middlewares/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/lvgl/src/widgets/list/: lv_list.c
    ../Middlewares/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/lvgl/src/widgets/menu/: lv_menu.c
    ../Middlewares/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Middlewares/lvgl/src/widgets/roller/: lv_roller.c
    ../Middlewares/lvgl/src/widgets/scale/: lv_scale.c
    ../Middlewares/lvgl/src/widgets/slider/: lv_slider.c
    ../Middlewares/lvgl/src/widgets/span/: lv_span.c
    ../Middlewares/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/lvgl/src/widgets/switch/: lv_switch.c
    ../Middlewares/lvgl/src/widgets/table/: lv_table.c
    ../Middlewares/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/lvgl/src/widgets/win/: lv_win.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Debug/RTT
    ../Debug/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0
